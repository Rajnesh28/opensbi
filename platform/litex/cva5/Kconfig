## platform/litex/cva5/Kconfig
```kconfig
# SPDX-License-Identifier: BSD-2-Clause

config PLATFORM_VEXRISCV_LITEX
   	bool
    select FDT
    select SERIAL_LITEX
    default y
```
